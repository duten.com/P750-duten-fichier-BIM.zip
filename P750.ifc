Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: Project Number
Time: 2021-11-16T16:44:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.2.1.1 - Alternate UI 19.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 16 16:44:30 2021 * Host: LAPTOP-F3NQTQR2 * Database: C:\Users\DIANEB~1\AppData\Local\Temp\{EB07ABBF-C8E4-4316-ABB5-A6ACF28F18B9}\ifc * Database version: 5507 * Database creation date: Tue Nov 16 16:44:30 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 16 16:44:30 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 16 16:44:30 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcBuildingElementProxy: Built-in trash can with introductory flap, DBLTD_Duten_LittrBins_P750:Built-in trash can with introductory flap:315016
In: Level 0
Type - Classification: C1030210 Bath & Toilet Accessories - Commercial (Uniformat); Material: Duten_Metal_SatinStainlessSteel, Duten_Metal_PolishedStainlessSteel
Pset_BuildingElementProxyCommon - Reference: n/a
Pset_ManufacturerTypeInformation - ModelReference: Recessed Bin; Manufacturer: Duten
